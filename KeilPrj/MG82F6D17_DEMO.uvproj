# Keil uVision project MG82F6D17_DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82F6D17 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0-0x2FF) CLOCK(25000000)
  output: MG82F6D17_DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../code/: MAIN.C rd_control.c rd_control.h
